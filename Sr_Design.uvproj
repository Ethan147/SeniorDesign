# Keil uVision project Sr_Design.uvproj, settings and files
target Sr_Design (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: ST7735
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source
    ./: startup.s PLL.c ST7735.c timer.c switch.c ADC.c FloatMultiply.s PWM.c main.c
