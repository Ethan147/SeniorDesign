# Keil uVision project Lab04.uvproj, settings and files
target Lab04 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab03
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: ADC.c DAC.c lcd.c motor.c Music.c PLL.c PWM.c speaker.c ST7735.c ST7735TestMain.c switch.c timer.c startup.s
